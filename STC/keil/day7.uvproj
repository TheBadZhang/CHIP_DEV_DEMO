# Keil uVision project day7.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: day7 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: day7.c binary.h buzz.h effect.h keyboard.h lcd1602.h led7seg.h led88.h motor.h myargs.h myheader.h
