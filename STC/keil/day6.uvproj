# Keil uVision project day6.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: day6 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: day6.c binary.h myheader.h myargs.h effect.h
